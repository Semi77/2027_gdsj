# Keil uVision project WHEELTEC.uvprojx, settings and files
target WHEELTEC (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WHEELTEC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../HARDWARE/ADC;../HARDWARE/Encoder;../HARDWARE/I2C;../HARDWARE/ICM20948;../HARDWARE/KEY;../HARDWARE/LED;../HARDWARE/OLED;../HARDWARE/TIM;../HARDWARE/USART_X;../SYSTEM/delay;../SYSTEM/sys;../SYSTEM/usart;../BALANCE/CONCTRL;../BALANCE/SHOW;../HARDWARE/MOTOR
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: servo_output.c chassis_link.c main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/I2C/: bsp_siic.c
    ../HARDWARE/ICM20948/: bsp_imu.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/USART_X/: usart_x.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/Encoder/: Encoder.c
  group BALANCE
    ../BALANCE/CONCTRL/: conctrl.c
    ../BALANCE/SHOW/: show.c
software components: CMSIS:CORE 4.3.0
